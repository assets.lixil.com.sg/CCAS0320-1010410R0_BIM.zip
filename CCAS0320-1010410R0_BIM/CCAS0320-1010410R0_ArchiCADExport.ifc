Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-09-16T18:17:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Alternate UI 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Sep 16 18:17:13 2022 * Host: DESKTOP-H3C3U9I * Database: C:\Users\nawap\AppData\Local\Temp\27bc0a6c-d02d-445f-baf6-6cc9c1aef3da\4f52a604-1146-4001-a6c3-5fb3ca389a74\ifc * Database version: 5507 * Database creation date: Fri Sep 16 18:17:12 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Sep 16 18:17:13 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Sep 16 18:17:13 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 ft

# IfcBuilding
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:Story Level, Level 1
LongName: Level 1; Elevation: 0 ft
Pset_ProductRequirements - Name: Level 1; Category: Levels
Pset_AirSideSystemInformation - Name: Level 1

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
Port_282750 | SINK
Port_282750 | SOURCE

# IfcFlowTerminal: CCAS0320-1010410R0_REVIT:Signature 550mm semi-counter basin, CCAS0320-1010410R0_REVIT:Signature 550mm semi-counter basin:282750
In: Level 1
Material: Vitreous China
Pset_DistributionFlowElementCommon - Reference: Signature 550mm semi-counter basin; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Pset_ProductRequirements - Category: Plumbing Fixtures
